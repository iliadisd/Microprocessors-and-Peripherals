# Keil uVision project HelloWorldC.uvprojx, settings and files
target HelloWorldC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: HelloWorldC
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 1300
  c include: ..\..\..\..\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: main.c
    ../../../../src/: Application.c
    ../../: SimulationPlatform.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1, Simulation:redBlocks Simulator:C Target Library Core 2.9.2
